# Keil uVision project AimBot.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AimBot
  AfterMake: fromelf -cvf .\Objects\AimBot.axf --vhx --32x1 -o AimBot.dat
  AfterMake: fromelf -cvf .\Objects\AimBot.axf -o AimBot.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.s
